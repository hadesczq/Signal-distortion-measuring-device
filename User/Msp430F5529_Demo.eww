<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Msp430F5529_Demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


