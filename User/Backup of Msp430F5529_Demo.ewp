# IAR project Backup of Msp430F5529_Demo.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ../$PROJ_DIR$; ../F5xx_F6xx_Core_Lib; ../MSP-EXP430F5529_HAL; ../Src; ../User
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group F5xx_F6xx_Core_Lib
    ../F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_PMAP.c HAL_PMM.c HAL_TLV.c HAL_UCS.c
  group MSP-EXP430F5529_HAL
    ../MSP-EXP430F5529_HAL/: ADC.c Clock.c HAL_AppUart.c HAL_Board.c HAL_Buttons.c HAL_Cma3000.c HAL_Dogs102x6.c HAL_Menu.c HAL_SDCard.c HAL_Wheel.c
  group Src
    ../Src/: Fourier.c KeyScan.C Ks0108.C Menu.C MenuFSM.C MenuFunc.C MenuLanguage.C MenuMain.C MenuMeasure.C MenuPara.C MenuTop.C
  group User
    ./: main.c
